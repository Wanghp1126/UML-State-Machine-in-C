# Keil uVision project hierarchical_state_machine.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hierarchical_state_machine
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSM_CONFIG
  c include: ..\hierarchical_state_machine;..\state_machine_framework
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group state_machine_framework
    ../state_machine_framework/: hsm.c
  group hierarchical_state_machine
    ./: demo.c main.c
software components: CMSIS:CORE 5.4.0, Device:GPIO 1.3, Device:Startup 1.0.0
